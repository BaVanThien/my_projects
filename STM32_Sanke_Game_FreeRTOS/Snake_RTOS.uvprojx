# Keil uVision project Snake_RTOS.uvprojx, settings and files
target RTOS (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Snake_RTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c include: .\Core;.\Driver;.\Lib;.\freertos\include;.\freertos\portable\MemMang;.\freertos\portable\GCC\ARM_CM3;.\App
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ./Core/: main.c main.h
  group Driver
    ./Driver/: ADC.c ADC.h AFIO.h CPIO.h EXTI.c EXTI.h GPIO.c I2C.c I2C.h RCC.c RCC.h SPI.c SPI.h Tim.c Tim.h TYPE.h UART.c UART.h button.c button.h
  group Lib
    ./Lib/: DS3231.c DS3231.h FONT.c FONT.h TFT.c TFT.h display.c display.h
  group freeRTOS
    ./freertos/: tasks.c timers.c croutine.c event_groups.c list.c queue.c
    ./freertos/include/: task.h timers.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h
    ./freertos/portable/GCC/ARM_CM3/: port.c portmacro.h
    ./freertos/portable/MemMang/: heap_4.c
  group App
    ./App/: game_logic.c game_logic.h task_snake.h task_snake.c task_input.h task_input.c
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0
