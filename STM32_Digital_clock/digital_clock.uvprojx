# Keil uVision project digital_clock.uvprojx, settings and files
target clock (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: digital_clock
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c include: .\Driver;.\Core;.\Lib
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ./Core/: main.h main.c Display_task.c Display_task.h UART_Task.c UART_task.h
    ./Driver/: BUTTON.c BUTTON.h
  group Driver
    ./Driver/: AFIO.h EXTI.c EXTI.h I2C.c I2C.h RCC.c RCC.h SPI.c SPI.h Tim.c Tim.h TYPE.h UART.c UART.h GPIO.h GPIO.c String.c String.h DMA.c DMA.h
  group Llib
    ./Lib/: DS3231.c DS3231.h FONT.c FONT.h TFT.c TFT.h
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0
